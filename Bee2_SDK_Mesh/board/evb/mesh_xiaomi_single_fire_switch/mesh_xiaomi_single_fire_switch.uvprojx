# Keil uVision project mesh_xiaomi_single_fire_switch.uvprojx, settings and files
target mesh_xiaomi_single_fire_switch (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DEVICE MI_MESH_ENABLED MI_ASSERT PRODUCT_ID=948 CUSTOMIZED_MI_CONFIG_FILE=<mijia_mesh_config.h>
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\app\mesh\lib;..\..\..\src\app\mesh\lib\lib;..\..\..\src\app\mesh\lib\platform;..\..\..\src\app\mesh\lib\gap;..\..\..\src\app\mesh\lib\cmd;..\..\..\src\app\mesh\lib\model;..\..\..\src\app\mesh\lib\model\realtek;..\..\..\src\app\mesh\lib\profile;..\..\..\src\app\mesh\lib\utility;..\..\..\src\app\mesh\lib\inc;..\..\..\src\app\mesh\lib\common;..\..\..\src\app\mesh\xiaomi_single_fire_switch;..\mesh_xiaomi_single_fire_switch;..\..\..\src\app\mesh\lib\common\xiaomi\api;..\..\..\src\app\mesh\lib\common\xiaomi\libs;..\..\..\src\app\mesh\lib\common\xiaomi;..\..\..\src\app\mesh\lib\common\xiaomi\libs\third_party;..\..\..\src\app\mesh\lib\model\xiaomi
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h
  group lib
    ../../../bin/: ROM.lib bee2_sdk.lib gap_utils.lib
    ../../../src/app/mesh/lib/lib/: mesh_dev.lib
    ../../../src/app/mesh/lib/common/xiaomi/libs/third_party/micro-ecc/: micro_ecc_m4f_le.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group io
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_tim.c rtl876x_uart.c rtl876x_gpio.c
  group model
    ../../../src/app/mesh/lib/model/: generic_transition_time.c delay_execution.c health_server.c generic_on_off_server.c light_lightness_server.c light_ctl_server.c light_ctl_temperature_server.c delay_msg_rsp.c
    ../../../src/app/mesh/lib/model/xiaomi/: miot_model_client.c miot_model_server.c mijia_server.c
  group app
    ../../../src/app/mesh/lib/utility/: dimmable_light.c
    ../../../src/app/mesh/lib/common/: light_controller_app.c light_effect_app.c light_storage_app.c light_cwrgb_app.c mesh_sdk.c
    ../../../src/app/mesh/lib/platform/: reset_watch_dog_timer.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/flash/: silent_dfu_flash.c
    ../../../src/app/mesh/xiaomi_single_fire_switch/: app_task.c single_fire_switch_ctl_server_app.c io_management.c light_sw_timer.c single_fire_switch_app.c main.c mi_cmd.c mijia_mp_cmd.c miot_model_client_app.c miot_model_server_app.c
    ../../../src/debug/backup/: hardfault_record.c
  group xiaomi
    ../../../src/app/mesh/lib/common/xiaomi/: mijia_mesh_app.c mijia_mp_cmd_parser.c mijia_mesh_publish.c
    ../../../src/app/mesh/lib/common/xiaomi/api/: rtk_gatt.c rtk_misc.c rtk_nvm.c rtk_os.c mible_api.c rtk_gap_mesh.c
    ../../../src/app/mesh/lib/common/xiaomi/libs/common/: crc32.c mible_beacon.c mible_crypto.c mible_rxfer.c queue.c tlv.c
    ../../../src/app/mesh/lib/common/xiaomi/libs/cryptography/: mi_crypto.c mi_crypto_backend_mbedtls.c mi_crypto_backend_msc.c mi_crypto_backend_uECC.c mi_mesh_otp.c
    ../../../src/app/mesh/lib/common/xiaomi/libs/gatt_dfu/: mible_dfu_auth.c mible_dfu_flash.c mible_dfu_main.c
    ../../../src/app/mesh/lib/common/xiaomi/libs/mesh_auth/: mible_mesh_auth.c
    ../../../src/app/mesh/lib/common/xiaomi/libs/third_party/mbedtls/: asn1parse.c ccm.c sha256_hkdf.c
    ../../../src/app/mesh/lib/common/xiaomi/libs/third_party/pt/: pt_misc.c
    ../../../src/app/mesh/lib/common/xiaomi/libs/mijia_profiles/: mi_service_server.c
