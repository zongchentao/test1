# Keil uVision project peripheral.uvprojx, settings and files
target ble_peripheral (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ENABLE_RTK_MESH=0 CUSTOMIZED_MI_CONFIG_FILE=<custom_mi_config.h>
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\sample\ble_peripheral;..\ble_peripheral;..\..\..\src\app\mesh\lib\common\xiaomi\api;..\..\..\src\app\mesh\lib\common\xiaomi;..\..\..\src\app\mesh\lib\platform\;mijia_ble_libs;..\mijia_ble_standard
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib bee2_sdk.lib
    ../../../src/app/mesh/lib/lib/: mesh_dev.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c
  group profile
    ../../../src/ble/profile/server/: simple_ble_service.c bas.c
    ../../../src/ble/profile/client/: ancs_client.c
  group app
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ./: main.c ancs.c app_task.c peripheral_app.c
    ../../../src/flash/: silent_dfu_flash.c
  group mijia_api
    ../../../src/app/mesh/lib/common/xiaomi/api/: mible_api.c rtk_gap.c rtk_gatt.c rtk_misc.c rtk_nvm.c rtk_os.c
  group standard_auth
    ./mijia_ble_libs/standard_auth/: stand-auth-cortex-m4f.lib
  group mijia_ble_libs/common
    ./mijia_ble_libs/common/: crc32.c mible_beacon.c mible_crypto.c mible_rxfer.c queue.c tlv.c
  group mijia_ble_libs/crypto
    ./mijia_ble_libs/cryptography/: mi_crypto.c mi_crypto_backend_mbedtls.c mi_crypto_backend_uECC.c
  group mijia_ble_libs/third_party
    ./mijia_ble_libs/third_party/pt/: pt_misc.c
    ./mijia_ble_libs/third_party/mbedtls/: asn1parse.c ccm.c sha256_hkdf.c
    ./mijia_ble_libs/third_party/micro-ecc/: micro_ecc_m4f_le.lib
  group mijia_ble_libs/mijia_profiles
    ./mijia_ble_libs/mijia_profiles/: mi_service_server.c stdio_service_server.c
    ./mijia_ble_libs/: mi_config.c
